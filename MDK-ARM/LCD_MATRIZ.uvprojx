# Keil uVision project LCD_MATRIZ.uvprojx, settings and files
target LCD_MATRIZ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD_MATRIZ
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;              ../Drivers/STM32F1xx_HAL_Driver/Inc;              ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;              ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c ST_LCD.c stm32f1xx_hal_uart.c ST_Matriz.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: ST_Matriz.h
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
software components: CMSIS:CORE 4.3.0
